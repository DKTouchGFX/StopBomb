<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\TSDHD-TSS013-1.ewp</path>
  </project>
  <batchBuild />
</workspace>
