# Keil uVision project TSDHD-TSS013-1.uvprojx, settings and files
target TSDHD-TSS013-1 (6140001::V6.14.1::ARMCLANG)
  device: STM32C091CCTx STMicroelectronics
  pack: Keil.STM32C0xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20008FFF) IROM(0x8000000-0x803FFFF)   CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: TSDHD-TSS013-1 +hex
  c flags: Optim=6 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32C091xx,KNOB_INTERFACE
  c include: ../TouchGFX/App;../TouchGFX/target/generated;../TouchGFX/target;../Core/Inc;../Drivers/STM32C0xx_HAL_Driver/Inc;../Drivers/STM32C0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32C0xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x9000
  scatter file: .\TSDHD-TSS013-1.sct
  group Application/MDK-ARM
    ./: startup_stm32c091xx.s
  group Application/User/Core
    ../Core/Src/: RVA15MD_DisplayDriver.c RVA15MD_DataReader.c knob_interface.cpp main.c stm32c0xx_it.c stm32c0xx_hal_msp.c
  group Application/User/TouchGFX/target
    ../TouchGFX/target/: KeySampler.cpp TouchGFXHAL.cpp STM32TouchController.cpp TouchGFXDataReader.cpp TouchGFXGPIO.cpp
  group Application/User/TouchGFX/target/generated
    ../TouchGFX/target/generated/: TouchGFXConfiguration.cpp TouchGFXGeneratedHAL.cpp STM32DMA.cpp TouchGFXGeneratedDataReader.cpp OSWrappers.cpp
  group Application/User/TouchGFX/App
    ../TouchGFX/App/: app_touchgfx.c
  group Drivers/STM32C0xx_HAL_Driver
    ../Drivers/STM32C0xx_HAL_Driver/Src/: stm32c0xx_hal.c stm32c0xx_hal_cortex.c stm32c0xx_hal_rcc.c stm32c0xx_hal_rcc_ex.c stm32c0xx_hal_flash.c stm32c0xx_hal_flash_ex.c stm32c0xx_hal_gpio.c stm32c0xx_hal_dma.c stm32c0xx_hal_dma_ex.c stm32c0xx_hal_pwr.c stm32c0xx_hal_pwr_ex.c stm32c0xx_hal_exti.c stm32c0xx_hal_crc.c stm32c0xx_hal_crc_ex.c stm32c0xx_hal_spi.c stm32c0xx_hal_spi_ex.c stm32c0xx_hal_tim.c stm32c0xx_hal_tim_ex.c stm32c0xx_hal_uart.c stm32c0xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32c0xx.c
software components: CMSIS:CORE 5.6.0
